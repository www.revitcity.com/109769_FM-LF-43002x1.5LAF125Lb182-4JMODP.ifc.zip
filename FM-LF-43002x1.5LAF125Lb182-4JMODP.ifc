Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: FM-LF-43002x1.5LAF125Lb182-4JMODP.ifc
Time: 2012-06-29T14:10:32
Author: ARMSTRONG
Organization: ARMSTRONG DESIGN PVT. LTD.,
Written by: SwIFC
Made in: SolidWorks 2011

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
